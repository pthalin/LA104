# IAR project LA104_APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; APP_MODE
  ICCARM.CCIncludePath2: Inc; Src; Inc\MSD; Src\MSD; ..\Libraries\CMSIS\Device\STM32F10x\Include; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LA104_APP.hex
  ILINK.IlinkOutputFile: LA104_APP.out
  ILINK.IlinkIcfFile: STM32F103_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group MSD
    Src/MSD/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group Prgm
    Src/: Analyze.c Bios.c Ctrl.c Disk.c Ext_Flash.c FAT12.c Files.c Func.c GUI.c Interrupt.c Main.c Menu.c
  group STM32F10x/CMSIS
    Src/: STM32F103_Startup.s STM32F103_System.c
  group STM32F10x/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
